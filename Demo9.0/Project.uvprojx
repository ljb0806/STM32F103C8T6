# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\system;.\OLED;.\UART;.\ADC;.\TIMER;.\SPI;.\I2C;.\AD9833;.\OV7670;.\SCCB;.\LCD;.\GPIOS;.\ADS8688;.\ADS1118;.\AD9954;.\TLV5638
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group system
    ./system/: Delay.c Delay.h GPIO.c GPIO.h
  group OLED
    ./OLED/: OLED.c OLED.h OLED_Font.h
  group UART
    ./UART/: Serial.c Serial.h Serial_2.c Serial_2.h Serial_3.c Serial_3.h
  group ADC
    ./ADC/: ADC_1.c ADC_1.h ADC_2.c ADC_2.h
  group TIMER
    ./TIMER/: Timer2.c Timer2.h
  group SPI
    ./SPI/: SPI_Hardware.c SPI_Hardware.h SPI_Software.c SPI_Software.h SPI2.c SPI2.h
  group I2C
    ./I2C/: I2C_Hardware.c I2C_Hardware.h I2C_Software.c I2C_Software.h
  group AD9833
    ./AD9833/: AD9833.c AD9833.h
  group OV7670
    ./OV7670/: OV7670.c OV7670.h OV7670_RegConfig.h
  group SCCB
    ./SCCB/: SCCB.c SCCB.h
  group LCD
    ./LCD/: LCD.c LCD.h
  group GPIOS
    ./GPIOS/: GPIOS.c GPIOS.h
  group ADS8688
    ./ADS8688/: ADS8688.c ADS8688.h
  group ADS1118
    ./ADS1118/: ADS1118.c ADS1118.h
  group AD9954
    ./AD9954/: AD9954.c AD9954.h
  group TLV5638
    ./TLV5638/: TLV5638.c TLV5638.h
